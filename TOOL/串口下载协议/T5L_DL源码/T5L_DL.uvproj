# Keil uVision project T5L_DL.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: T5L_DGo +hex
  c flags: Optimize=3
  c include: .\T5LDrv
  link misc: REMOVEUNUSED
  group Main
    ./: main.c STARTUP_M5.A51
  group T5LDriver
    ./T5LDriver/: T5LDriver.C T5LUart2.c T5LUart4.c
